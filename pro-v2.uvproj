# Keil uVision project pro-v2.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: pro-v2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Headers;
  group H
    ./Headers/: REG_89C51.h type_var_H.h Key_Pad_3x4.h Delays_H.h DStructure.h ADC0808_H.h Speedometer.h lcd_TC1602B.h ISD25120.h OUTPUTS.h Doors_h.h
  group C
    ./: Prog.c
